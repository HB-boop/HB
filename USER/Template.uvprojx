# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\HARDWARE\delay;..\STM32F10x_FWLib\inc;..\USER;..\uCOSIII\APP;..\uCOSIII\BSP;..\uCOSIII\uC-CPU;..\uCOSIII\uC-LIB;..\uCOSIII\uC-Ports;..\uCOSIII\uC-Source;..\HARDWARE\LED;..\HARDWARE\usart1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ./: oled.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/usart1/: usart1.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../uCOSIII/APP/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../uCOSIII/BSP/: bsp.c
  group uC-CPU
    ../uCOSIII/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group uC-LIB
    ../uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_mem_a.asm lib_str.c
  group uC-Ports
    ../uCOSIII/uC-Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC-Source
    ../uCOSIII/uC-Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
